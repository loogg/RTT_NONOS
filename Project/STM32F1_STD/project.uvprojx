# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output .\build\rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;..\..\rt-thread\include;applications;.;board;board\config\inc;board\ports;..\..\drivers\STM32_F1xx_STD_Drivers;..\..\drivers\STM32_F1xx_STD_Drivers\config;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m3;..\..\rt-thread\components\finsh;..\..\rt-thread\components\utilities\ymodem;..\..\libraries\STM32F1xx_STD\CMSIS\CM3\CoreSupport;..\..\libraries\STM32F1xx_STD\STM32F10x_StdPeriph_Driver\inc;..\..\libraries\STM32F1xx_STD\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Kernel
    ../../rt-thread/src/: clock.c components.c idle.c kservice.c scheduler.c thread.c
  group Applications
    applications/: main.c ymodem_ota.c
  group Drivers
    board/: board.c
    board/config/src/: stm32f1xx_std_msp.c stm32f10x_it.c system_stm32f10x.c
    ../../libraries/STM32F1xx_STD/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../drivers/STM32_F1xx_STD_Drivers/: drv_usart.c drv_common.c drv_flash.c
  group cpu
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group Utilities
    ../../rt-thread/components/utilities/ymodem/: ymodem.c
  group STM32_STD
    ../../libraries/STM32F1xx_STD/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../libraries/STM32F1xx_STD/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
