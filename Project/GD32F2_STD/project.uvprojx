# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F205RC GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output .\build\rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32F20X_CL
  c include: .;..\..\rt-thread\include;applications;.;board;board\config\inc;board\ports;..\..\drivers\GD32_STD_Drivers;..\..\drivers\GD32_STD_Drivers\config;func;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m3;..\..\rt-thread\components\finsh;..\..\rt-thread\components\utilities\ymodem;..\..\libraries\GD32F20x_STD\CMSIS;..\..\libraries\GD32F20x_STD\CMSIS\GD\GD32F20x\Include;..\..\libraries\GD32F20x_STD\GD32F20x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Kernel
    ../../rt-thread/src/: clock.c components.c idle.c kservice.c scheduler.c thread.c
  group Applications
    applications/: main.c ymodem_ota.c
  group Drivers
    board/: board.c
    board/config/src/: gd32f2xx_std_msp.c gd32f20x_it.c system_gd32f20x.c
    ../../libraries/GD32F20x_STD/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
    ../../drivers/GD32_STD_Drivers/: drv_usart.c drv_common.c drv_flash.c
  group func
    func/: jump_app.c mem.c util.c
  group cpu
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group Utilities
    ../../rt-thread/components/utilities/ymodem/: ymodem.c
  group GD32_Lib
    ../../libraries/GD32F20x_STD/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
